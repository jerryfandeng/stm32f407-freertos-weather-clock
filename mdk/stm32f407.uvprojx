# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\app;..\app\font;..\app\image;..\app\page;..\driver\cpu_tick;..\driver\rtc;..\driver\console;..\driver\aht20;..\driver\st7789;..\driver\esp_at;..\driver\tim_delay;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib\Easylogger\inc;..\third_lib\freertos\include;..\third_lib\freertos\portable;..\third_lib\cm_backtrace\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c wifi.c weather.c ui.c app.c workqueue.c
  group app/font
    ../app/font/: font16_maple.c font20_maple_bold.c font24_maple_semibold.c font24_maple_bold.c font32_maple_bold.c font54_maple_bold.c font54_maple_semibold.c font64_maple_extrabold.c font76_maple_extrabold.c
  group app/image
    ../app/image/: img_meihua.c img_error.c img_wifi.c icon_wifi.c icon_wenduji.c icon_duoyun.c icon_leizhenyu.c icon_qing.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c icon_na.c img_choose.c
  group app/page
    ../app/page/: error_page.c wifi_page.c main_page.c
  group driver
    ../driver/rtc/: rtc.c
    ../driver/console/: console.c
    ../driver/aht20/: aht20.c
    ../driver/st7789/: st7789.c
    ../driver/esp_at/: esp_at.c
    ../driver/tim_delay/: tim_delay.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/freertos
    ../third_lib/freertos/: list.c queue.c tasks.c timers.c
    ../third_lib/freertos/portable/: port.c heap_4.c
  group third_lib/Easylogger
    ../third_lib/Easylogger/: elog.c elog_async.c elog_buf.c elog_port.c elog_utils.c
  group third_lib/cmbacktrace
    ../third_lib/cm_backtrace/: cm_backtrace.c cmb_fault.S
